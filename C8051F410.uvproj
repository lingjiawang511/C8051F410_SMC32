# Keil uVision project C8051F410.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F410 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(50000000)
  output: C8051F410 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c lock.c timer0.c led.c uart.c button.c variable_init.c
